# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/BSP/STM32F429I-Discovery;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/HID/inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/inc;../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Utilities
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.h stm32f429i_discovery_sdram.h stm32f429i_discovery_lcd.h stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_spi.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2c.c stm32f4xx_ll_rcc.c stm32f4xx_ll_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_gpio.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_sdram.h stm32f4xx_hal_spi.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_ll_cortex.h stm32f4xx_ll_dma.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ili9341/: ili9341.c ili9341.h
  group Example/User
    ../Src/: main.c stm32f4xx_it.c Graphics.c
    ../Inc/: Sprites.h main.h
software components: CMSIS:CORE 4.3.0
